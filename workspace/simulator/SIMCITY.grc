options:
  parameters:
    generate_options: qt_gui
    id: nadafunciona
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\ariel\OneDrive\Desktop\workspace\simulator\TEST_OOK_NOGAIN.bin
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\ariel\OneDrive\Desktop\workspace\TEST_OOK_AGC2.bin
    type: float
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\ariel\OneDrive\Desktop\workspace\SENT.bin
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\ariel\OneDrive\Desktop\workspace\originalsignalnoH.bin
    type: float
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: C:\Users\ariel\OneDrive\Documentos\modulatingcosine.bin
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\ariel\OneDrive\Desktop\workspace\envioOOKyDATA.bin
    repeat: 'False'
    type: float
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\ariel\OneDrive\Desktop\dataOG.bin
    repeat: 'False'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Transmitted"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Received"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: radio
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: radio
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_float_1, '0']
- [analog_agc2_xx_0, '0', qtgui_time_sink_x_1, '1']
- [analog_sig_source_x_0, '0', blocks_complex_to_float_2, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_complex_to_float_0_1, '0', blocks_file_sink_1, '0']
- [blocks_complex_to_float_1, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_float_2, '0', blocks_file_sink_2, '0']
- [blocks_file_source_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_repeat_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_float_0_1, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '0']
- [blocks_repeat_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', analog_agc2_xx_0, '0']
- [virtual_source_0, '0', blocks_complex_to_float_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
