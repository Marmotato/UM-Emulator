options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: prbs_test
    output_language: python
    run_options: run
  states: {}

blocks:
- name: SNR
  id: variable_qtgui_entry
  parameters:
    label: SNR
    type: real
    value: '12'
  states: {}
- name: cfo
  id: variable_qtgui_range
  parameters:
    label: Freq Offset
    start: '-1e-1'
    step: '1e-3'
    stop: '1e-1'
    value: '0'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: frame_width
  id: variable
  parameters:
    value: 1024*2
  states: {}
- name: pream
  id: variable
  parameters:
    value: (mapper.preamble_generator(32,511,1033)).get_preamble()
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sro
  id: variable_qtgui_range
  parameters:
    label: Sample Rate Offset
    start: '-1e-1'
    step: '1e-3'
    stop: '1e-1'
    value: '0'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/xbee/Desktop/textoinput.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: 1.0+sro
    freq_offset: cfo
    noise_voltage: (10**(-SNR/10.0))*np.sqrt(samp_per_sym)
    seed: '0'
    taps: '[1]'
  states: {}
- name: channels_dynamic_channel_model_0
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: 0.0,0.1,1.3
    fD: '2.0'
    mags: 1,0.99,0.97
    noise_amp: '1.0'
    ntaps: '8'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: complex
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: samp_per_sym
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '1e-2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_sym
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from cmath import exp, pi; from random import randint; import numpy as np;
  states: {}
- name: mapper_mapper_0
  id: mapper_mapper
  parameters:
    modtype: mapper.BPSK
    symbol_values: '[0,1]'
  states: {state: disabled}
- name: mapper_prbs_sink_b_0
  id: mapper_prbs_sink_b
  parameters:
    reset_len: frame_width-len(pream)
    which_mode: '"PRBS31"'
  states: {}
- name: mapper_prbs_source_b_0
  id: mapper_prbs_source_b
  parameters:
    reset_len: frame_width-len(pream)
    which_mode: '"PRBS31"'
  states: {}
- name: mapper_preamble_insert_bb_0
  id: mapper_preamble_insert_bb
  parameters:
    preamble: pream
    width: frame_width
  states: {}
- name: mapper_preamble_sync_demapper_0
  id: mapper_preamble_sync_demapper
  parameters:
    acquire_bit_thresh: '1'
    loose_bit_thresh: '3'
    modtype: mapper.BPSK
    passthrough: 'False'
    preamble: pream
    symbol_map: '[0,1]'
    width: frame_width
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: QT GUI Plot
    size: 840-84
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: QT GUI Plot
    size: 840-84
    type: complex
    xmax: '0.0015'
    xmin: '-0.0015'
    ymax: '0.0015'
    ymin: '-0.0015'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '1'
    interp: samp_per_sym
    ntaps: '11'
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '1'
    interp: samp_per_sym*0+1
    ntaps: '11'
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: interp_fir_filter_ccf
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: samp_rate
    dev_addr: addr=192.168.10.3
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: samp_rate
    dev_addr: addr=192.168.10.2
    dev_args: '""'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: comm
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: comm
  states: {}

connections:
- [blocks_file_source_0, '0', mapper_preamble_insert_bb_0, '0']
- [blocks_throttle2_0, '0', root_raised_cosine_filter_0, '0']
- [channels_channel_model_0, '0', uhd_usrp_sink_1, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', mapper_prbs_sink_b_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', mapper_preamble_sync_demapper_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', mapper_preamble_sync_demapper_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [mapper_mapper_0, '0', blocks_throttle2_0, '0']
- [mapper_prbs_source_b_0, '0', mapper_preamble_insert_bb_0, '0']
- [mapper_preamble_insert_bb_0, '0', digital_constellation_modulator_0, '0']
- [mapper_preamble_insert_bb_0, '0', mapper_mapper_0, '0']
- [mapper_preamble_sync_demapper_0, '0', digital_binary_slicer_fb_0, '0']
- [root_raised_cosine_filter_0, '0', channels_channel_model_0, '0']
- [root_raised_cosine_filter_0_0, '0', digital_costas_loop_cc_0, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_const_sink_x_0, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_1, '0', root_raised_cosine_filter_0_0, '0']
- [virtual_source_0, '0', root_raised_cosine_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
