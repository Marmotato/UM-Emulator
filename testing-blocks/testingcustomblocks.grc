options:
  parameters:
    generate_options: qt_gui
    id: testingcustomblocks
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '3000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: emu_vars
  id: epy_module
  parameters:
    source_code: "import numpy as np\n\n# posición Ti\nx_i = 3\ny_i = 0.5\nz_i = 4.5\n\n# posición Rj1    \nx_j = 3\ny_j = 1\nz_j = 1.8\n\n# posición del Rj2     \nx_j2 = 3\ny_j2 = 1.5\nz_j2 = 1.8\n\n# posición del Rj3    \nx_j3 = 4\ny_j3 = 2\nz_j3 = 1.8\n\n# posición del Rj4    \nx_j4 = 2.2\ny_j4 = 2.5\nz_j4 = 1.8\n\n# posición del Rj5    \nx_j5 = 1\ny_j5 = 2.5\nz_j5 = 1.6\n\n# posición del área reflectiva (pared) usar para puntos específicos de elementos reflectantes\n\n# first reflection_point \nx_w1 = 2\ny_w1 = 2\nz_w1 = 3\n\n# second reflection_point\nx_w2 = 1.5\ny_w2 = 2.3\nz_w2 = 4.0\n\n# third reflection_point\nx_w = 5\ny_w = 2.9\nz_w = 3.5\n\n# position of scattering particle\n# x_s = 4\n# y_s = 4.5\n# z_s = 2.5\n\n# parámetros de la simulación\n\nAw = 1                                        # área del elemento reflectante\npw = 0.6                                      # coeficiente de reflexión del área reflectiva\nang_rad = 60                                  # semi-ángulo de mitad de potencia del LED\nm = int(-np.log(2) / np.log(abs(np.cos(ang_rad * np.pi / 180))));   # número Lambertiano\nAp = 0.0001                                   # área física del receptor (1 cm^2)\neta = 1.5                                     # índice de refracción del PD\nfov = 70                                      # field of view\n\n# parámetros de los ángulos de inclinación y rotación\n\nbeta_i = 45                                   # ángulo de inclinación del LED con respecto al eje z\nalpha_i = 45                                  # ángulo de rotación del LED con respecto al eje x\n\nbeta_j = 45                                   # ángulo de inclinación del PD con respecto al eje z\nalpha_j = 45                                  # ángulo de rotación del PD con respecto al eje x\n\n# wall rotation angles para ángulo específico                   \nalpha_w = 20\nbeta_w = 70\n\ngv = [20, 60]                                 # distribución uniforme de probabilidad  \nfv = [0, 5]                                   # distribución uniforme de probabilidad   \nW = 6                                         # ancho del obstáculo\nH = 5                                         # altura del obstáculo\nX = 6                                         # Longitud de la mina\nY = 3                                         # altura de la mina\nes = 5                                        # epsilon \nt = 5 * 10**-9                                # valor del tiempo\ngymma = 0.017                                 # coeficiente de reflexión\ng = 0.72                                      # responsividad\nf = 0.5                                       # índice de refracción\nkr = [0.1, 0.01]                              # distribución uniforme de probabilidad\nkm = [0, 10]                                  # distribución uniforme de probabilidad\nks = np.add(kr, km)                           # distribución uniforme de probabilidad\nN = 70                                        # Número de scatterers\n# rn=sqrt((x_j-x_s)^2+(y_j-y_s)^2+(z_j-z_s)^2);\np = 0.1                                       # el parámetro se utiliza en el cálculo de Gn debajo de la ecuación 3.21 \n\nc = 3 * 10**8                                 # velocidad de la luz\n\nSampling_time = 0.25e-9                       # 0.25 nano segundos de muestreo, se disminuye para mayor número de muestras\ntime = np.arange(0, 35e-9, Sampling_time)    # vector de tiempo donde se observará el CIR\ntime = np.round(time)                         # redondeo del tiempo \nt_rise = 0.5e-9                               # subida del tiempo de subida del PD\nt_fall = 1e-9                                 # tiempo de caída del PD\nh_led = 10 * (np.exp(-time / t_fall) - np.exp(-time / t_rise))  # respuesta al impulso del PD\n\n"
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, additionFlag=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Add or Multiply Block',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.additionFlag = additionFlag

          def work(self, input_items, output_items):
              """example: add or multiply based on flag"""
              if self.additionFlag:
                  output_items[0][:] = input_items[0][:] + input_items[1][:]
              else:
                  output_items[0][:] = input_items[0][:] * input_items[1][:]
              return len(output_items[0])
    additionFlag: 'True'
    alias: Add or Multiply
  states: {}
- name: epy_module_1
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [analog_sig_source_x_1, '0', epy_block_0, '1']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
