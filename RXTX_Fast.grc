options:
  parameters:
    generate_options: qt_gui
    id: TXRXscript
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centerfreq
  id: variable
  parameters:
    value: 0.5e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: TEST_OOK_NOGAIN.bin
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\ariel\OneDrive\Desktop\workspace\TEST_OOK_AGC2.bin
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: SENT.bin
    type: float
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: INTERPOLATED_SENT_SIGNAL.bin
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: originalsignalnoH.bin
    type: float
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: RX_QUAD.bin
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: envioOOKyDATA.bin
    repeat: 'False'
    type: float
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\ariel\OneDrive\Desktop\workspace\dataOG.bin
    repeat: 'False'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.05'
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*3.14/100
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Transmitted"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Received"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: centerfreq
    dev_addr: addr=192.168.10.3
    dev_args: '""'
    gain0: '1'
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: centerfreq
    dev_addr: addr=192.168.10.3
    dev_args: '""'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: emu
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: emu
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_float_1, '0']
- [analog_agc2_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_file_sink_2, '0']
- [blocks_complex_to_float_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_complex_to_float_0_0_0, '0', blocks_file_sink_0_1_0, '0']
- [blocks_complex_to_float_1, '0', blocks_file_sink_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_file_sink_1, '0']
- [blocks_float_to_complex_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_complex_to_float_0_0_0, '0']
- [blocks_float_to_complex_0, '0', channels_channel_model_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '0', analog_agc2_xx_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', analog_agc2_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', digital_costas_loop_cc_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0, '0', analog_agc2_xx_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
